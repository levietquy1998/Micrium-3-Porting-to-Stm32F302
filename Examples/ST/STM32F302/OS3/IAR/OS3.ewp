# IAR project OS3.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302K6 ST STM32F302K6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F302x8; NDEBUG
  ICCARM.CCIncludePath2: ..\; ..\..\BSP; ..\..\BSP\OS\uCOS-III; ..\..\..\STM32CubeF3\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\STM32CubeF3\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\..\Software\uC-CPU; ..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\Software\uC-LIB; ..\..\..\..\..\Software\uCOS-III\Source; ..\..\..\..\..\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\..\Software\uC-Serial\Driver\ST; ..\..\..\..\..\Software\uC-Serial\Line; ..\..\..\..\..\Software\uC-Serial\OS; ..\..\..\..\..\Software\uC-Serial\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OS.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\stm32f302x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../: app.c app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f3xx_hal_conf.h
  group APP/Serial
    ../: app_serial.c app_serial.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c cpu_bsp.c serial_bsp_stm3240x.c serial_bsp_stm3240x.h
  group BSP/CMSIS
    ../../BSP/CMSIS/: system_stm32f3xx.c
  group BSP/IAR
    ../../BSP/IAR/: cstartup.c stm32f302x8_flash.icf
  group BSP/OS/uCOS-III
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group STM32CubeF3/Drivers/CMSIS/Device/ST/STM32F3xx/Include
    ../../../STM32CubeF3/Drivers/CMSIS/Device/ST/STM32F3xx/Include/: stm32f302x8.h stm32f3xx.h system_stm32f3xx.h
  group STM32CubeF3/Drivers/STM32F3xx_HAL_Driver/Inc
    ../../../STM32CubeF3/Drivers/STM32F3xx_HAL_Driver/Inc/: stm32_assert_template.h stm32f3xx_hal.h stm32f3xx_hal_adc.h stm32f3xx_hal_adc_ex.h stm32f3xx_hal_can.h stm32f3xx_hal_cec.h stm32f3xx_hal_comp.h stm32f3xx_hal_comp_ex.h stm32f3xx_hal_conf_template.h stm32f3xx_hal_cortex.h stm32f3xx_hal_crc.h stm32f3xx_hal_crc_ex.h stm32f3xx_hal_dac.h stm32f3xx_hal_dac_ex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_hrtim.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_i2s.h stm32f3xx_hal_i2s_ex.h stm32f3xx_hal_irda.h stm32f3xx_hal_irda_ex.h stm32f3xx_hal_iwdg.h stm32f3xx_hal_nand.h stm32f3xx_hal_nor.h stm32f3xx_hal_opamp.h stm32f3xx_hal_opamp_ex.h stm32f3xx_hal_pccard.h stm32f3xx_hal_pcd.h stm32f3xx_hal_pcd_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_rtc.h stm32f3xx_hal_rtc_ex.h stm32f3xx_hal_sdadc.h stm32f3xx_hal_smartcard.h stm32f3xx_hal_smartcard_ex.h stm32f3xx_hal_smbus.h stm32f3xx_hal_spi.h stm32f3xx_hal_spi_ex.h stm32f3xx_hal_sram.h stm32f3xx_hal_tim.h stm32f3xx_hal_tim_ex.h stm32f3xx_hal_tsc.h stm32f3xx_hal_uart.h stm32f3xx_hal_uart_ex.h stm32f3xx_hal_usart.h stm32f3xx_hal_usart_ex.h stm32f3xx_hal_wwdg.h stm32f3xx_ll_adc.h stm32f3xx_ll_bus.h stm32f3xx_ll_comp.h stm32f3xx_ll_cortex.h stm32f3xx_ll_crc.h stm32f3xx_ll_dac.h stm32f3xx_ll_dma.h stm32f3xx_ll_exti.h stm32f3xx_ll_fmc.h stm32f3xx_ll_gpio.h stm32f3xx_ll_hrtim.h stm32f3xx_ll_i2c.h stm32f3xx_ll_iwdg.h stm32f3xx_ll_opamp.h stm32f3xx_ll_pwr.h stm32f3xx_ll_rcc.h stm32f3xx_ll_rtc.h stm32f3xx_ll_spi.h stm32f3xx_ll_system.h stm32f3xx_ll_tim.h stm32f3xx_ll_usart.h stm32f3xx_ll_utils.h stm32f3xx_ll_wwdg.h
  group STM32CubeF3/Drivers/STM32F3xx_HAL_Driver/Inc/Legacy
    ../../../STM32CubeF3/Drivers/STM32F3xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h stm32f3xx_hal_can_legacy.h
  group STM32CubeF3/Drivers/STM32F3xx_HAL_Driver/Src
    ../../../STM32CubeF3/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_msp_template.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_adc.c stm32f3xx_ll_comp.c stm32f3xx_ll_crc.c stm32f3xx_ll_dac.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_fmc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_hrtim.c stm32f3xx_ll_i2c.c stm32f3xx_ll_opamp.c stm32f3xx_ll_pwr.c stm32f3xx_ll_rcc.c stm32f3xx_ll_rtc.c stm32f3xx_ll_spi.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
  group uC/CPU
    ../../../../../Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M4/IAR
    ../../../../../Software/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../../../../../Software/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-III/Ports/ARM-Cortex-M4/Generic/IAR
    ../../../../../Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../../../../../Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/Serial/Driver/ST
    ../../../../../Software/uC-Serial/Driver/ST/: serial_drv_stm32.c serial_drv_stm32.h
  group uC/Serial/Line
    ../../../../../Software/uC-Serial/Line/: serial_line_dflt.c serial_line_dflt.h serial_line_probe.c serial_line_probe.h serial_line_tty.c serial_line_tty.h
  group uC/Serial/OS
    ../../../../../Software/uC-Serial/OS/: serial_os.h
  group uC/Serial/OS/uCOS-III
    ../../../../../Software/uC-Serial/OS/uCOS-III/: serial_os.c
  group uC/Serial/Source
    ../../../../../Software/uC-Serial/Source/: serial.c serial.h serial_buf.c serial_buf.h serial_type.h
