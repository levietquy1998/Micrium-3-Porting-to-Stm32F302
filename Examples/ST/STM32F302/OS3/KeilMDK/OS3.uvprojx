# Keil uVision project OS3.uvprojx, settings and files
target FLASH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F302R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OS3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F302x8
  c include: ..\;..\..\BSP;..\..\BSP\OS\uCOS-III;..\..\..\STM32CubeF3\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\STM32CubeF3\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\Software\uC-CPU;..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\..\Software\uC-LIB;..\..\..\..\..\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\..\Software\uCOS-III\Source;..\..\..\..\..\Software\uC-Serial\Driver\ST;..\..\..\..\..\Software\uC-Serial\Line;..\..\..\..\..\Software\uC-Serial\OS;..\..\..\..\..\Software\uC-Serial\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ../: app.c app_cfg.h app_serial.c app_serial.h cpu_cfg.h lib_cfg.h os_cfg.h os_app_hooks.c os_app_hooks.h os_cfg_app.h stm32f3xx_hal_conf.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c cpu_bsp.c serial_bsp_stm3240x.c serial_bsp_stm3240x.h gpio.c gpio.h
    ../../BSP/KeilMDK/: startup.s
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
    ../../BSP/CMSIS/: system_stm32f3xx.c
  group STM32CubeF4 CMSIS
    ../../../STM32CubeF3/Drivers/CMSIS/Device/ST/STM32F3xx/Include/: stm32f3xx.h stm32f302x8.h system_stm32f3xx.h
  group uC-CPU
    ../../../../../Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../../../../Software/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC-LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../Software/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC-Serial
    ../../../../../Software/uC-Serial/Source/: serial.c serial.h serial_buf.c serial_buf.h serial_type.h
    ../../../../../Software/uC-Serial/OS/uCOS-III/: serial_os.c
    ../../../../../Software/uC-Serial/OS/: serial_os.h
    ../../../../../Software/uC-Serial/Line/: serial_line_dflt.c serial_line_dflt.h serial_line_probe.c serial_line_probe.h serial_line_tty.c serial_line_tty.h
    ../../../../../Software/uC-Serial/Driver/ST/: serial_drv_stm32.c serial_drv_stm32.h
  group uCOS-III Source
    ../../../../../Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uCOS-III Ports
    ../../../../../Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group STM32CubeF3 HAL-Drivers
    ../../../STM32CubeF3/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_msp_template.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_adc.c stm32f3xx_ll_comp.c stm32f3xx_ll_crc.c stm32f3xx_ll_dac.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_fmc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_hrtim.c stm32f3xx_ll_i2c.c stm32f3xx_ll_opamp.c stm32f3xx_ll_pwr.c stm32f3xx_ll_rcc.c stm32f3xx_ll_rtc.c stm32f3xx_ll_spi.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
